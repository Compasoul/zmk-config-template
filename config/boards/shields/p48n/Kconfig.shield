## config/boards/shields/p48n/Kconfig.shield
```kconfig
# Copyright (c) 2020 The ZMK Contributors
# SPDX-License-Identifier: MIT

config SHIELD_P48N
    def_bool $(shields_list_contains,p48n)
```
